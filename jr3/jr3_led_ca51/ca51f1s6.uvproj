# Keil uVision project ca51f1s6.uvproj, settings and files
target CA51F (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: ca51f1s6 +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Files
    ./source/: main.c delay.c system_clock.c uart.c interrupt.c
  group Lib
    ./lib/: STARTUP.A51
