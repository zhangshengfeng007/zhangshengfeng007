# Keil uVision project JR3.uvprojx, settings and files
target Target 1 (MCS-51)
  device: SN8F5703 SONiX
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF5) CLOCK(32000000) DPC
  output: JR3 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\App\inc;..\Driver\inc
  group App
    ../App/: system.c work.c display.c key.c fan.c touch_key.c charge.c touch.c ntc.c error_det.c sleep.c burnin.c
  group Driver
    ../Driver/: pwm_driver.c timer.c adc_driver.c bs83b.c 74HC595.c rotary.c
  group User
    ../User/: main.c
  group Core
    ../Core/: OPTIONS_SN8F5703.A51 STARTUP.A51
