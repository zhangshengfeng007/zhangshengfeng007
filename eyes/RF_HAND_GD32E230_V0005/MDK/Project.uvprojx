# Keil uVision project Project.uvprojx, settings and files
target GD32E23x (6130001::V6.13.1::.\ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: ABF_206_V0003 +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230
  c include: ..\CMSIS;..\Peripherals\Include;..\CMSIS\GD\GD32E23x\Include;..\Core;..\UserDriver;..\UserApp
  library: MicroLIB
  memory RVCT4: ROM 0x8002800 size 0xd400
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Core
    ../Core/: gd32e23x_it.c
  group UserApp
    ../UserApp/: task_app.c test_app.c key_app.c device_app.c main.c common.c led_app.c err_check_app.c
  group UserDriver
    ../UserDriver/: drv_gpio.c drv_delay.c drv_adc.c drv_ems.c drv_key.c drv_motor.c drv_power.c drv_rf.c drv_sensor.c drv_flash.c drv_uart.c drv_ems_rf_en_pin.c drv_led.c
  group Peripherals
    ../Peripherals/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group CMSIS
    ../CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
    ../CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
software components: CMSIS:CORE 5.2.0
